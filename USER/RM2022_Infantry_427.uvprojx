# Keil uVision project RM2022_Infantry_427.uvprojx, settings and files
target Infantry (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM2022_Infantry_427 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__FPU_USED =1
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\inc;..\CORE;..\HARDWARE\LED;..\HARDWARE\CAN;..\HARDWARE\DR16;..\HARDWARE\CHASSIS;..\HARDWARE\CAN_HANDLE;..\HARDWARE\POWER;..\HARDWARE\BEEP;..\HARDWARE\GRAY;..\HARDWARE\TRACE;..\HARDWARE\ASTAR;..\HARDWARE\INFRARED;..\HARDWARE\SERVO;..\HARDWARE;..\TOOL
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/CAN_HANDLE/: can_handle.c
    ../HARDWARE/DR16/: dr16.c
    ../HARDWARE/CHASSIS/: chassis.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/POWER/: power.c
    ../HARDWARE/GRAY/: gray.c
    ../HARDWARE/TRACE/: trace.c
    ../HARDWARE/INFRARED/: infrared.c
    ../HARDWARE/ASTAR/: Astar.c
    ../HARDWARE/SERVO/: servo.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_exti.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f427xx.s
  group TOOL
    ../TOOL/: ramp.c
